options:
  parameters:
    author: Johannes Demel
    category: '[GFDM]'
    generate_options: hb
    id: hier_gfdm_receiver_stream
    output_language: python
    title: GFDM Receiver
  states: {}

blocks:
- name: block_len
  id: variable
  parameters:
    value: timeslots * subcarriers
  states: {}
- name: frame_len
  id: variable
  parameters:
    value: preamble_len + cp_len + cs_len + block_len
  states: {}
- name: internal_frame_start_tag_key
  id: variable
  parameters:
    value: f"{frame_start_tag_key}{antenna_port}"
  states: {}
- name: preamble_len
  id: variable
  parameters:
    value: cp_len + len(preamble) + cs_len
  states: {}
- name: activate_cfo_compensation
  id: parameter
  parameters:
    label: Activate CFO compensation
    type: intx
    value: '1'
  states: {}
- name: active_subcarriers
  id: parameter
  parameters:
    label: Active subcarriers
    type: intx
    value: '52'
  states: {}
- name: antenna_port
  id: parameter
  parameters:
    label: Antenna port
    type: intx
    value: '0'
  states: {}
- name: chan
  id: pad_sink
  parameters:
    label: Channel Estimate
    optional: 'True'
    type: complex
  states: {}
- name: compensate_phase
  id: parameter
  parameters:
    label: Do phase compensation
    type: intx
    value: '0'
  states: {}
- name: cp_len
  id: parameter
  parameters:
    label: CP length
    type: intx
    value: '16'
  states: {}
- name: cs_len
  id: parameter
  parameters:
    label: CS length
    type: intx
    value: '8'
  states: {}
- name: frame_len
  id: parameter
  parameters:
    label: Frame length
    type: intx
    value: '800'
  states: {state: disabled}
- name: frame_start_tag_key
  id: parameter
  parameters:
    label: Tag key
    type: str
    value: '"frame_start"'
  states: {}
- name: gfdm_advanced_receiver_sb_cc_0
  id: gfdm_advanced_receiver_sb_cc
  parameters:
    constellation: gfdm_constellation
    do_phase_compensation: compensate_phase
    frequency_taps: rx_filter_taps
    ic_iter: ic_iterations
    minoutbuf: block_len
    overlap: overlap
    subcarrier_map: subcarrier_map
    subcarriers: subcarriers
    timeslots: timeslots
  states: {}
- name: gfdm_channel_estimator_cc_0
  id: gfdm_channel_estimator_cc
  parameters:
    active_subcarriers: active_subcarriers
    fft_len: subcarriers
    is_dc_free: 'True'
    minoutbuf: block_len
    preamble: preamble
    timeslots: timeslots
    which_estimator: which_estimator
  states: {}
- name: gfdm_constellation
  id: parameter
  parameters:
    value: digital.constellation_qpsk().base()
  states: {}
- name: gfdm_extract_burst_cc_0
  id: gfdm_extract_burst_cc
  parameters:
    burst_len: frame_len
    burst_start_tag: frame_start_tag_key
    forward_burst_start_tag: internal_frame_start_tag_key
    minoutbuf: frame_len
    tag_backoff: cp_len
    use_cfo_compensation: activate_cfo_compensation
  states: {}
- name: gfdm_remove_prefix_cc_data
  id: gfdm_remove_prefix_cc
  parameters:
    block_len: block_len
    frame_len: frame_len
    gfdm_sync_tag_key: internal_frame_start_tag_key
    minoutbuf: block_len
    offset: preamble_len + cp_len
  states: {}
- name: gfdm_remove_prefix_cc_preamble
  id: gfdm_remove_prefix_cc
  parameters:
    block_len: len(preamble)
    frame_len: frame_len
    gfdm_sync_tag_key: internal_frame_start_tag_key
    minoutbuf: block_len
    offset: cp_len
  states: {}
- name: gfdm_resource_demapper_cc_0
  id: gfdm_resource_demapper_cc
  parameters:
    active_subcarriers: active_subcarriers
    minoutbuf: timeslots * active_subcarriers
    per_timeslot: 'True'
    subcarrier_map: subcarrier_map
    subcarriers: subcarriers
    timeslots: timeslots
  states: {}
- name: ic_iterations
  id: parameter
  parameters:
    label: IC iterations
    type: intx
    value: '2'
  states: {}
- name: import_digital
  id: import
  parameters:
    imports: from gnuradio import digital
  states: {}
- name: import_numpy
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: overlap
  id: parameter
  parameters:
    label: Overlap
    type: intx
    value: '2'
  states: {}
- name: pad_sink_out
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}
- name: preamble
  id: parameter
  parameters:
    label: Core preamble
    value: np.ones(2 * 64)
  states: {}
- name: ramp_len
  id: parameter
  parameters:
    label: Ramp length
    type: intx
    value: '8'
  states: {}
- name: rx_filter_taps
  id: parameter
  parameters:
    label: RX filter taps
    value: np.ones(10)
  states: {}
- name: subcarrier_map
  id: parameter
  parameters:
    label: Subcarrier map
    value: np.arange(52)
  states: {}
- name: subcarriers
  id: parameter
  parameters:
    label: Subcarriers
    type: intx
    value: '64'
  states: {}
- name: timeslots
  id: parameter
  parameters:
    label: Timeslots
    type: intx
    value: '15'
  states: {}
- name: which_estimator
  id: parameter
  parameters:
    label: Estimator Type
    type: intx
    value: '0'
  states: {}

connections:
- [gfdm_advanced_receiver_sb_cc_0, '0', gfdm_resource_demapper_cc_0, '0']
- [gfdm_channel_estimator_cc_0, '0', chan, '0']
- [gfdm_channel_estimator_cc_0, '0', gfdm_advanced_receiver_sb_cc_0, '1']
- [gfdm_extract_burst_cc_0, '0', gfdm_remove_prefix_cc_data, '0']
- [gfdm_extract_burst_cc_0, '0', gfdm_remove_prefix_cc_preamble, '0']
- [gfdm_remove_prefix_cc_data, '0', gfdm_advanced_receiver_sb_cc_0, '0']
- [gfdm_remove_prefix_cc_preamble, '0', gfdm_channel_estimator_cc_0, '0']
- [gfdm_resource_demapper_cc_0, '0', pad_sink_out, '0']
- [pad_source_0, '0', gfdm_extract_burst_cc_0, '0']

metadata:
  file_format: 1
